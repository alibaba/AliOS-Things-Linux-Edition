FILESEXTRAPATHS_prepend := "${THISDIR}/busybox:"

COMPATIBLE_MACHINE_mont-panther = "mont-panther"

SRC_URI += "file://network.cfg \
           "
