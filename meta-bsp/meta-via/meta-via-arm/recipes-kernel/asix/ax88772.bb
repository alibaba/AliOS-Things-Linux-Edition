SUMMARY = "AX88772 driver"
LICENSE = "CLOSED"

inherit module

SRC_URI = "file://AX88772C_772B_772A_760_772_178_LINUX_DRIVER_v4.21.0_Source.tar.bz2"

S = "${WORKDIR}/AX88772C_772B_772A_760_772_178_LINUX_DRIVER_v4.21.0_Source"
