# Copyright (C) 2018 Fuzhou Rockchip Electronics Co., Ltd
# Released under the MIT license (see COPYING.MIT for the terms)

FILESEXTRAPATH := "${THISDIR}/files/linux-yocto_${LINUX_VERSION}"

require linux-yocto-rt.inc
