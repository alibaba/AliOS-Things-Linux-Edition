FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += " \
	file://0001-libbb-speed_table.c-survive-B115200-and-B230400-not-.patch \
"
