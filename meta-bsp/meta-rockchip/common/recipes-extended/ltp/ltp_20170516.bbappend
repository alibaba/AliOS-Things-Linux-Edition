FILESEXTRAPATHS_prepend := "${THISDIR}/ltp:"

SRC_URI += "file://0001-remove-cases-for-rk3308.patch"
