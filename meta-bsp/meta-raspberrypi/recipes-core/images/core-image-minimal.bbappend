# Include modules in rootfs
IMAGE_INSTALL += " \
	kernel-modules \
	"
