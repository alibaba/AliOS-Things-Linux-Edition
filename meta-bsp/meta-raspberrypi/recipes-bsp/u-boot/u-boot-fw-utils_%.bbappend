require ${@oe.utils.all_distro_features(d, 'uota', 'u-boot-uota.inc')}

