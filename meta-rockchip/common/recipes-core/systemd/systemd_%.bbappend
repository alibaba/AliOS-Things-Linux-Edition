# Avoid installing hwdb
EXTRA_OEMAKE += " dist_udevhwdb_DATA="
