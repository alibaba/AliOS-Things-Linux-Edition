CACHED_CONFIGUREVARS_class-native = " FORCE_UNSAFE_CONFIGURE=1"
