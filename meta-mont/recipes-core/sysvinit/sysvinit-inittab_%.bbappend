FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

USE_VT = "0"
