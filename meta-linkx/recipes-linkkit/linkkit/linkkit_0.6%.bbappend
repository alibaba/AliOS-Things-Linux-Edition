FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}/0.6:"

SRC_URI += " \
           file://0001-BugID-17103492-LINKX-LINKKIT-report-os-version-in-Cl.patch \
           "
