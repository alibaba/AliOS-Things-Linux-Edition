# Add psplash boot splash screen
IMAGE_INSTALL += "psplash"
SPLASH = "psplash-alios-things"
