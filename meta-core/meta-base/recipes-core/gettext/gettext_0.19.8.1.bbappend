FILES_${PN}_append_libc-bionic = " ${libdir}/charset.alias"