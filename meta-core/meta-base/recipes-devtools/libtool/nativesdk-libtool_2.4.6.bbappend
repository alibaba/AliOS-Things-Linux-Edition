require libtool-bionic.inc