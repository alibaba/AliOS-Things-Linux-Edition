require gcc-bionic.inc