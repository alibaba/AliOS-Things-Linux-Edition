require gcc-bionic.inc
RUNTIMETARGET_remove_libc-bionic = "libmpx"