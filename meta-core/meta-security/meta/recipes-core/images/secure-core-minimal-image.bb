require secure-core-image.inc
