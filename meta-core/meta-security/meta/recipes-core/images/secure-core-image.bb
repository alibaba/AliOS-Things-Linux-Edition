require secure-core-image.inc

IMAGE_INSTALL += "\
    packagegroup-core-lsb \
"
