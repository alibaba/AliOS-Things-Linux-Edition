
require include/alios-image-secure.inc

