RDEPENDS_${PN} += "lvm2 lvm2-udevrules"
