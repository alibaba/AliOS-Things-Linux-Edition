require libuv.inc

SRC_URI[md5sum] = "e373b76ba7d85c3b9370777487e4300c"
SRC_URI[sha256sum] = "a6ca9f0648973d1463f46b495ce546ddcbe7cce2f04b32e802a15539e46c57ad"
