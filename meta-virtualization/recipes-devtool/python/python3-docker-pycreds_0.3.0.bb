SUMMARY = "Python bindings for the docker credentials store API"
HOMEPAGE = "https://github.com/shin-/dockerpy-creds"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3b83ef96387f14655fc854ddc3c6bd57"

inherit pypi setuptools3

SRC_URI[md5sum] = "2370ea3b62198b788a26231ab58844af"
SRC_URI[sha256sum] = "8b0e956c8d206f832b06aa93a710ba2c3bcbacb5a314449c040b0b814355bbff"
