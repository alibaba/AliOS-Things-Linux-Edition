COMPATIBLE_MACHINE += "|raspberrypi3-64"
CFLAGS_append_libc-bionic = " -fuse-ld=bfd"
