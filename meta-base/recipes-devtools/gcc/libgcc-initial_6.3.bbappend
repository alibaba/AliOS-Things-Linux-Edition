require gcc-bionic.inc
DEPENDS_append_libc-bionic = " virtual/${TARGET_PREFIX}libc-initial"