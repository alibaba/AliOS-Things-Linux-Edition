DEFAULT_TIMEZONE = "PRC"
INSTALL_TIMEZONE_FILE = "1"
