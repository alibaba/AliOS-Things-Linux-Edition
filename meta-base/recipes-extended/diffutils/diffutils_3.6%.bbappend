FILESEXTRAPATHS_prepend := "${THISDIR}/diffutils-3.6:"
SRC_URI += "file://fix_build_error_with_glibc_2.24.patch"
