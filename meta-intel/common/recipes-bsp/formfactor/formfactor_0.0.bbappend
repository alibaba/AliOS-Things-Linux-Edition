FILESEXTRAPATHS_prepend_intel-x86-common := "${THISDIR}/${PN}:"
