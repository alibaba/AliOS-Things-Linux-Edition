IMAGE_INSTALL += "optee-test-qoriq optee-client-qoriq"
