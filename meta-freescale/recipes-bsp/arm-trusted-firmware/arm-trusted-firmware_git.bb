ATF_VERSION = "1.5"
SRCREV = "f7c5f30799a2c2431f1fccd5c79229492629e0ec"

include arm-trusted-firmware.inc
