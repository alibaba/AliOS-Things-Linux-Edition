require linux-yocto-efi-secure-boot.inc
