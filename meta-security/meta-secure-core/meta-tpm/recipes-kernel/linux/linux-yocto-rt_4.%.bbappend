require linux-yocto-tpm.inc
