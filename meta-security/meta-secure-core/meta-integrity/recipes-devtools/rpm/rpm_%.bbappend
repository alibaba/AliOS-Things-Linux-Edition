require rpm-integrity.inc
