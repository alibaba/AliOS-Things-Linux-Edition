require linux-yocto-integrity.inc
