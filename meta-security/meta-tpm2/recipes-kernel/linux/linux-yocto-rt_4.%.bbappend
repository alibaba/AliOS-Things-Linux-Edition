require linux-yocto-tpm2.inc
